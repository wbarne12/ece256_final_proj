# Keil uVision project Lab7.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: ARMCM4 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: Lab8
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source
    ./: main.c startup.s lab7.c systick.c GPIOinit.h GPIOinit.c
  group Dependencies
    ./driverlib/: adc.c cpu.c gpio.c interrupt.c sysctl.c uart.c
    ./utils/: uartstdio.c
